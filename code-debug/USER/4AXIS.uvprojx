# Keil uVision project 4AXIS.uvprojx, settings and files
target 4AXIS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 4AXIS +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED = 1,ARM_MATH_CM4,__CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\PWM;..\FWLIB\inc;..\HARDWARE\IIC;..\HARDWARE\SPI;..\HARDWARE\MPU6050;..\HARDWARE\NRF24L01;..\RTOS\inc;..\RTOS;..\RTOS\RVDS\ARM_CM4F;..\HARDWARE\TIMER;..\SOFTWARE\inc;C:\Keil_v5\ARM\PACK\ARM\CMSIS\4.5.0\CMSIS\Include;..\HARDWARE\STMFLASH;..\HARDWARE\ADC;..\HARDWARE\MS5611
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\OBJ\4AXIS.sct
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c crc16.c
    $TC_ROOT$/PACK/ARM/CMSIS/4.5.0/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../../code-lib/OBJ/: 4AXIS.lib
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MS5611/: MS5611.c
    ../HARDWARE/HMC5883L/: HMC5883L.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_adc.c
  group README
    ../: readme.txt
  group RTOS
    ../RTOS/src/: croutine.c list.c queue.c tasks.c timers.c
    ../RTOS/MemMang/: heap_2.c
    ../RTOS/RVDS/ARM_CM4F/: port.c portmacro.h
    ../RTOS/: FreeRTOSConfig.h
  group 4AXIS
    ../SOFTWARE/src/: ControlAlgorithm.c DataAcquisition.c FlyControl.c MotorOutput.c RemoteReceive.c StateManage.c UIManage.c nvram.c outputdata.c
    ../SOFTWARE/inc/: System.h
